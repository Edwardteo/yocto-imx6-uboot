## board/teo/mx6pixiet/Kconfig
```kconfig
if TARGET_MX6PIXIET

config SYS_BOARD
	default "mx6pixiet"

config SYS_VENDOR
	default "teo"

config SYS_CONFIG_NAME
	default "mx6pixiet"

endif
```
